options:
  parameters:
    author: zjhao
    generate_options: qt_gui
    id: cad_Test
    output_language: python
    title: cad_Test
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 500e3/4
  states: {}
- name: freq
  id: variable
  parameters:
    value: 470.3e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: lora_cad_0
  id: lora_cad
  parameters:
    fft_factor: '16'
    fs_bw_ratio: '2'
    spreading_factor: sf
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: bw
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_addr: ''
    dev_args: '""'
    gain0: '1'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [lora_cad_0, CAD, blocks_message_debug_0, print_pdu]
- [uhd_usrp_source_0, '0', lora_cad_0, '0']

metadata:
  file_format: 1
