options:
  parameters:
    author: zjhao
    generate_options: qt_gui
    id: RTS_Send
    output_language: python
    title: RTS_Send
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: code_rate
  id: variable
  parameters:
    value: '4'
  states: {}
- name: crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 470.3e6
  states: {}
- name: header
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: ldr
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: spreading_factor
  id: variable
  parameters:
    value: '7'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (2 * math.pi * offset) / samp_rate
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52002'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: lora_RTS_Sender_0
  id: lora_RTS_Sender
  parameters:
    Duration: '100'
    NodeId: '1'
  states: {}
- name: lora_decode_0
  id: lora_decode
  parameters:
    code_rate: code_rate
    crc: crc
    header: header
    low_data_rate: ldr
    payload_len: payload_len
    spreading_factor: spreading_factor
  states: {}
- name: lora_demod_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: code_rate
    crc: crc
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: ldr
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: spreading_factor
  states: {}
- name: lora_encode_0
  id: lora_encode
  parameters:
    code_rate: code_rate
    crc: 'False'
    header: header
    low_data_rate: ldr
    spreading_factor: spreading_factor
  states: {}
- name: lora_mod_0
  id: lora_mod
  parameters:
    spreading_factor: spreading_factor
    sync_word: '0x34'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: bw/2+10e3
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: note_2
  id: note
  parameters:
    note: Resample to the desired bandwidth.
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 2*bw/samp_rate
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: samp_rate/bw
    type: ccf
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: bw
    center_freq0: frequency
    dev_args: '""'
    gain0: '30'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: bw
    center_freq0: frequency
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '30'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_rotator_cc_0, '0', pfb_arb_resampler_xxx_0_0, '0']
- [blocks_socket_pdu_0, pdus, lora_RTS_Sender_0, inmsg]
- [lora_RTS_Sender_0, '0', low_pass_filter_0, '0']
- [lora_RTS_Sender_0, outmsg, lora_encode_0, in]
- [lora_decode_0, header, lora_demod_0, header]
- [lora_decode_0, out, blocks_message_debug_0, print_pdu]
- [lora_decode_0, out, lora_RTS_Sender_0, inCTS]
- [lora_demod_0, out, lora_decode_0, in]
- [lora_encode_0, out, lora_mod_0, in]
- [lora_mod_0, '0', blocks_rotator_cc_0, '0']
- [low_pass_filter_0, '0', pfb_arb_resampler_xxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', lora_demod_0, '0']
- [pfb_arb_resampler_xxx_0_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', lora_RTS_Sender_0, '0']

metadata:
  file_format: 1
